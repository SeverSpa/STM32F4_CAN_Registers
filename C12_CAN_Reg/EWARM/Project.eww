<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\C12_CAN_Reg.ewp</path>
  </project>
  <batchBuild />
</workspace>
